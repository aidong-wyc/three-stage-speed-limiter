# Keil uVision project usbh_hid.uvprojx, settings and files
target usbh_hid (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usbh_hid +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F30X_CL,USE_LCD
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\..\..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F30x_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32F30x_usbfs_library\host\core\Include;..\..\..\..\..\Firmware\GD32F30x_usbfs_library\host\class\hid\Include;..\..\..\..\..\Firmware\GD32F30x_usbfs_library\ustd\common;..\..\..\..\..\Firmware\GD32F30x_usbfs_library\ustd\class\hid;..\..\..\..\..\Utilities\LCD_Commom;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c gd32f30x_it.c gd32f30x_usb_hw.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../../../../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
  group GD32F30x_EVAL
    ../../../../../Utilities/LCD_Commom/: lcd_font.c
    ../../../../../Utilities/: gd32f307c_lcd_eval.c
    ../src/: gd32f307c_eval.c lcd_log.c
  group USB_Driver
    ../../../../../Firmware/GD32F30x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32F30x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../Firmware/GD32F30x_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
