# Keil uVision project projet.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: GD32F303RB GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.6.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: speed_limit +hex
  AfterMake: cmd.exe /c if not exist ".\OUT" mkdir ".\OUT"
  AfterMake: cmd.exe /c copy /Y ".\Objects\speed_limit.hex" ".\OUT\speed_limit.hex"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,HXTAL_VALUE=24000000
  c include: .\libraries\Firmware\CMSIS;.\libraries\Firmware\CMSIS\GD\GD32F30x\Include;.\libraries\Firmware\GD32F30x_standard_peripheral\Include;.\user;.\code
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./user/: main.c gd32f30x_it.c systick.c system_gd32f30x.c
  group App
    ./code/: bsp_board.c bsp_debug_uart.c rs485.c modbus_crc.c modbus_slave.c bsp_adc.c bsp_dac.c param_store.c app_limiter.c
  group Startup
    ./libraries/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Peripherals
    ./libraries/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_rcu.c gd32f30x_misc.c gd32f30x_gpio.c gd32f30x_usart.c gd32f30x_timer.c gd32f30x_adc.c gd32f30x_dac.c gd32f30x_dma.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_wwdgt.c gd32f30x_pmu.c gd32f30x_bkp.c gd32f30x_rtc.c gd32f30x_crc.c gd32f30x_dbg.c
